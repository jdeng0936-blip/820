# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_LIBC, RT_USING_ARMLIBC, __RTTHREAD__, STM32F429xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS
  c include: ..\..\..\components\libc\posix\delay;..\..\..\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\net\sal\include\socket;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\drivers\ktime;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\net\sal\include;packages\mbedtls-v2.28.1\ports\inc;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;board\CubeMX_Config\Inc;..\..\..\components\drivers\include;packages\stm32f4_cmsis_driver-latest\Include;..\..\..\libcpu\arm\cortex-m4;applications;..\..\..\components\net\netdev\include;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;.;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\stm32f4_hal_driver-latest\Inc\Legacy;..\..\..\components\libc\posix\ipc;packages\CMSIS-Core-latest\Include;packages\SEGGER_RTT-latest;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\drivers;packages\SEGGER_RTT-latest\RTT;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\net\sal\include\socket\sys_socket;board\ports;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\ktime\inc;packages\stm32f4_hal_driver-latest\Inc;packages\mbedtls-v2.28.1\mbedtls\include;..\..\..\components\drivers\phy;packages\cJSON-v1.7.17;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\include;packages\at24cxx-latest;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;board;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\finsh;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\drivers\include;packages\mbedtls-v2.28.1\mbedtls\library
  memory RVCT4: ROM 0x8004000 size 0x19c000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: can_task.c settings.c m2m.c main.c relay.c
  group at24cxx
    packages/at24cxx-latest/: at24cxx.c
  group cJSON
    packages/cJSON-v1.7.17/: cJSON.c cJSON_Utils.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/ports/: drv_spi.c spi_flash_init.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_rtc.c drv_sdram.c drv_soft_i2c.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh_parse.c msh.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c kstring.c kstdio.c rt_vsscanf.c rt_vsnprintf_tiny.c
  group ktime
    ../../../components/drivers/ktime/src/: boottime.c cputimer.c hrtimer.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group mbedtls
    packages/mbedtls-v2.28.1/mbedtls/library/: mps_trace.c ssl_cache.c error.c oid.c bignum.c psa_crypto_mac.c ssl_cookie.c ecdh.c ssl_ciphersuites.c blowfish.c ctr_drbg.c md.c pkcs5.c psa_crypto_storage.c aes.c hmac_drbg.c x509_crt.c rsa.c version.c chacha20.c sha512.c platform_util.c camellia.c certs.c ecp_curves.c threading.c psa_crypto_driver_wrappers.c aria.c x509.c ccm.c md2.c psa_crypto_slot_management.c asn1write.c ecjpake.c platform.c ssl_cli.c pkcs11.c entropy_poll.c pem.c cmac.c x509write_csr.c pk.c ripemd160.c base64.c timing.c x509_crl.c pkparse.c ssl_srv.c des.c mps_reader.c pkwrite.c psa_its_file.c asn1parse.c ecdsa.c x509write_crt.c arc4.c psa_crypto_hash.c psa_crypto_client.c constant_time.c psa_crypto_ecp.c psa_crypto_se.c havege.c chachapoly.c memory_buffer_alloc.c psa_crypto_aead.c cipher.c entropy.c xtea.c md5.c psa_crypto.c version_features.c cipher_wrap.c x509_csr.c pk_wrap.c ssl_msg.c ecp.c sha1.c nist_kw.c ssl_tls.c debug.c gcm.c x509_create.c padlock.c poly1305.c psa_crypto_rsa.c ssl_ticket.c dhm.c hkdf.c md4.c psa_crypto_cipher.c aesni.c sha256.c pkcs12.c rsa_internal.c ssl_tls13_keys.c
    packages/mbedtls-v2.28.1/ports/src/: md5_alt.c rsa_alt.c aes_alt.c tls_certificate.c arc4_alt.c sha1_alt.c tls_client.c timing_alt.c tls_hardware.c des_alt.c sha256_alt.c sha512_alt.c tls_net.c
  group POSIX
    ../../../components/libc/posix/delay/: delay.c
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group SEGGER_RTT
    packages/SEGGER_RTT-latest/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    packages/SEGGER_RTT-latest/adapter/: drv_rtt.c
  group STM32F4-CMSIS
    packages/stm32f4_cmsis_driver-latest/Source/Templates/: system_stm32f4xx.c
    packages/stm32f4_cmsis_driver-latest/Source/Templates/arm/: startup_stm32f429xx.s
  group STM32F4-HAL
    packages/stm32f4_hal_driver-latest/Src/: stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_gpio.c stm32f4xx_hal_can.c stm32f4xx_ll_fmc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal.c stm32f4xx_hal_qspi.c stm32f4xx_hal_tim.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cryp.c stm32f4xx_hal_lptim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cec.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.15.0
