# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_HAL_DRIVER, STM32F429xx, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, RT_USING_LIBC
  c include: .;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\posix\io\poll;packages\stm32f4_hal_driver-latest\Inc\Legacy;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;board;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\components\drivers\phy;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;board\ports;packages\stm32f4_hal_driver-latest\Inc;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\libc\posix\io\eventfd;applications;packages\SEGGER_RTT-latest;packages\stm32f4_cmsis_driver-latest\Include;..\libraries\HAL_Drivers\drivers;board\CubeMX_Config\Inc;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\libraries\HAL_Drivers\drivers\config;packages\CMSIS-Core-latest\Include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\libc\compilers\common\extension;..\..\..\components\finsh;..\libraries\HAL_Drivers;..\..\..\libcpu\arm\cortex-m4;packages\SEGGER_RTT-latest\RTT;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal
  memory RVCT4: ROM 0x81a0000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c dummy.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_rtc.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    board/ports/: spi_flash_init.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_file.c shell.c msh.c cmd.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsscanf.c kstdio.c kstring.c kerrno.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group SEGGER_RTT
    packages/SEGGER_RTT-latest/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    packages/SEGGER_RTT-latest/adapter/: drv_rtt.c
  group STM32F4-CMSIS
    packages/stm32f4_cmsis_driver-latest/Source/Templates/: system_stm32f4xx.c
    packages/stm32f4_cmsis_driver-latest/Source/Templates/arm/: startup_stm32f429xx.s
  group STM32F4-HAL
    packages/stm32f4_hal_driver-latest/Src/: stm32f4xx_hal_usart.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_crc.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cec.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_cryp.c
