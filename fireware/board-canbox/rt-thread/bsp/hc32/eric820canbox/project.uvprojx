# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000)  IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, HC32F460, __RTTHREAD__, USE_DDL_DRIVER, RT_USING_LIBC, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __DEBUG
  c include: ..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;board\config;..\..\..\components\drivers\include;..\libraries\hc32f460_ddl\hc32_ll_driver\inc;..\..\..\components\drivers\include;board\config\usb_config;..\..\..\components\drivers\phy;board;packages\SEGGER_RTT-latest\RTT;..\..\..\components\drivers\include;.;..\..\..\components\libc\posix\io\eventfd;..\libraries\hc32f460_ddl\cmsis\Include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m4;applications;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\drivers\include;..\tests;board\ports;..\..\..\components\libc\compilers\common\extension;..\libraries\hc32_drivers\drv_flash;..\..\..\include;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\common;..\libraries\hc32f460_ddl\cmsis\Device\HDSC\hc32f4xx\Include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;packages\SEGGER_RTT-latest;..\..\..\components\libc\posix\io\poll;..\libraries\hc32_drivers;..\..\..\components\drivers\smp_call;..\..\..\components\libc\compilers\common\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: adc_work.c led_work.c xtal32_fcm.c can_work.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32f460_ddl/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f460.s
    ../libraries/hc32_drivers/: drv_adc.c drv_can.c drv_common.c drv_gpio.c drv_hwtimer.c drv_i2c.c drv_irq.c drv_rtc.c drv_soft_i2c.c drv_usart.c
    ../libraries/hc32_drivers/drv_flash/: drv_flash_f4.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh.c shell.c msh_file.c cmd.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsscanf.c kstdio.c kstring.c kerrno.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/hc32f460_ddl/hc32_ll_driver/src/: hc32_ll_tmra.c hc32_ll_efm.c hc32_ll_adc.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_tmr0.c hc32_ll_clk.c hc32_ll_ots.c hc32_ll_i2c.c hc32_ll_rtc.c hc32_ll_rmu.c hc32_ll_utility.c hc32_ll_aos.c hc32_ll_cmp.c hc32_ll_fcm.c hc32_ll_event_port.c hc32_ll_i2s.c hc32_ll_can.c hc32_ll_emb.c hc32_ll_dma.c hc32_ll_tmr6.c hc32_ll.c hc32_ll_mpu.c hc32_ll_usart.c hc32_ll_tmr4.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32f460_ll_interrupts_share.c hc32_ll_sram.c hc32_ll_pwc.c hc32_ll_icg.c hc32_ll_gpio.c hc32_ll_fcg.c
    ../libraries/hc32f460_ddl/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group SEGGER_RTT
    packages/SEGGER_RTT-latest/RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
    packages/SEGGER_RTT-latest/adapter/: drv_rtt.c
  group Tests
    ../tests/: test_fal.c test_can.c test_rtc.c test_adc.c test_uart_v1.c test_hwtimer.c test_gpio.c
